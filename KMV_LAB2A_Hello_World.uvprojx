# Keil uVision project KMV_LAB2A_Hello_World.uvprojx, settings and files
target KMV_LAB2A_Hello_World (6220000::V6.22::ARMCLANG)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.13.1.0
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff0000,0x010000) IROM(0x00000000,0x100000) XRAM(0x20000000,0x030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KMV_LAB2A_Hello_World
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: MBED_RAM_SIZE=0x30000 TOOLCHAIN_ARM TARGET_Freescale DEVICE_EMAC=1 TOOLCHAIN_ARM_STD DEVICE_SERIAL_ASYNCH=1 MULADDC_CANNOT_USE_R7 DEVICE_FLASH=1 COMPONENT_NSPE=1 DEVICE_PORTINOUT=1 DEVICE_SPISLAVE=1 DEVICE_LPTICKER=1 TARGET_KPSDK_CODE COMPONENT_SD=1 DEVICE_PORTIN=1 DEVICE_USTICKER=1 DEVICE_RTC=1 DEVICE_RESET_REASON=1 TARGET_NAME=K64F MBED_TICKLESS TARGET_KSDK2_MCUS MBED_RAM1_START=0x1fff0000 TARGET_MCUXpresso_MCUS MBED_BUILD_TIMESTAMP=1722633985.7925491 DEVICE_CRC=1 MBED_TRAP_ERRORS_ENABLED=1 DEVICE_I2CSLAVE=1 TARGET_K64F DEVICE_TRNG=1 MBED_SPLIT_HEAP TARGET_PSA MBED_ROM_START=0x0 DEVICE_SERIAL_FC=1 TARGET_LIKE_MBED DEVICE_PWMOUT=1 TARGET_M4 DEVICE_I2C=1 DEVICE_USBDEVICE=1 DEVICE_WATCHDOG=1 DEVICE_SPI_ASYNCH=1 TARGET_LIKE_CORTEX_M4 MBED_RAM_START=0x20000000 DEVICE_SLEEP=1 COMPONENT_PSA_SRV_EMUL=1 DEVICE_PORTOUT=1 DEVICE_SPI=1 TARGET_RELEASE __ASSERT_MSG MBED_ROM_SIZE=0x100000 __MBED__=1 FSL_RTOS_MBED CPU_MK64FN1M0VMD12 TARGET_Freescale_EMAC COMPONENT_PSA_SRV_IMPL=1 DEVICE_INTERRUPTIN=1 DEVICE_ANALOGIN=1 TARGET_MCU_K64F DEVICE_ANALOGOUT=1 MBED_RAM1_SIZE=0x10000 __CMSIS_RTOS DEVICE_SERIAL=1 DEVICE_STDIO_MESSAGES=1 TARGET_FRDM TOOLCHAIN_ARMC6 TARGET_RTOS_M4_M7 __CORTEX_M4 __FPU_PRESENT=1 MBED_DEBUG ARM_MATH_CM4 __MBED_CMSIS_RTOS_CM TARGET_CORTEX TARGET_KPSDK_MCUS TARGET_FF_ARDUINO TARGET_CORTEX_M COMPONENT_FLASHIAP=1
  c misc: -Wno-armcc-pragma-push-pop -fno-exceptions -Wno-armcc-pragma-anon-unions -fshort-wchar -fdata-sections -c -Wno-reserved-user-defined-literal -mfloat-abi=hard -mthumb -mcpu=cortex-m4 -fshort-enums -g -mfpu=fpv4-sp-d16 -Wno-deprecated-register -fno-rtti --target=arm-arm-none-eabi -include mbed_config.h
  c include: .;BUILD;BUILD/K64F;BUILD/K64F/ARMC6;mbed-os;mbed-os/cmsis;mbed-os/cmsis/TARGET_CORTEX_M;mbed-os/components;mbed-os/components/802.15.4_RF;mbed-os/components/802.15.4_RF/atmel-rf-driver;mbed-os/components/802.15.4_RF/mcr20a-rf-driver;mbed-os/components/802.15.4_RF/stm-s2lp-rf-driver;mbed-os/components/TARGET_PSA;mbed-os/components/storage/blockdevice/COMPONENT_FLASHIAP;mbed-os/components/storage/blockdevice/COMPONENT_SD;mbed-os/components/wifi;mbed-os/components/wifi/esp8266-driver;mbed-os/drivers;mbed-os/drivers/internal;mbed-os/events;mbed-os/features;mbed-os/features/cellular;mbed-os/features/device_key;mbed-os/features/frameworks;mbed-os/features/frameworks/TARGET_PSA;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/mbed-client-cli;mbed-os/features/frameworks/mbed-client-randlib;mbed-os/features/frameworks/mbed-coap;mbed-os/features/frameworks/mbed-trace;mbed-os/features/frameworks/nanostack-libservice;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/utest;mbed-os/features/lorawan;mbed-os/features/lwipstack;mbed-os/features/mbedtls;mbed-os/features/nanostack;mbed-os/features/nanostack/coap-service;mbed-os/features/nanostack/mbed-mesh-api;mbed-os/features/nanostack/nanostack-hal-mbed-cmsis-rtos;mbed-os/features/nanostack/nanostack-interface;mbed-os/features/nanostack/sal-stack-nanostack;mbed-os/features/nanostack/sal-stack-nanostack-eventloop;mbed-os/features/netsocket;mbed-os/features/nfc;mbed-os/features/storage;mbed-os/features/storage/blockdevice;mbed-os/features/storage/filesystem;mbed-os/features/storage/kvstore;mbed-os/features/storage/kvstore/conf;mbed-os/features/storage/kvstore/direct_access_devicekey;mbed-os/features/storage/kvstore/filesystemstore;mbed-os/features/storage/kvstore/global_api;mbed-os/features/storage/kvstore/include;mbed-os/features/storage/kvstore/kv_map;mbed-os/features/storage/kvstore/securestore;mbed-os/features/storage/kvstore/tdbstore;mbed-os/features/storage/nvstore;mbed-os/features/storage/system_storage;mbed-os/hal;mbed-os/hal/storage_abstraction;mbed-os/hal/usb;mbed-os/platform;mbed-os/platform/cxxsupport;mbed-os/platform/internal;mbed-os/platform/source;mbed-os/platform/source/TARGET_CORTEX_M;mbed-os/platform/source/minimal-printf;mbed-os/rtos;mbed-os/targets/TARGET_Freescale;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers;mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api;/Volumes/Extreme Pro 2 TB/Extras/KEIL_WORKSPACE/Keil_Lab2A_Hello_World/KMV_LAB2A_Hello_World/mbed-os
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-DMBED_TICKLESS,-DCPU_MK64FN1M0VMD12,-D__FPU_PRESENT=1,-DARM_MATH_CM4,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M4,-DFSL_RTOS_MBED,-DMBED_SPLIT_HEAP
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: ROM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .link_script.sct
  link misc: --keep=os_cb_sections --remove --predefine="-DMBED_BOOT_STACK_SIZE=4096" --verbose --predefine="-DMBED_RAM_START=0x20000000" --legacyalign --show_full_path --cpu=Cortex-M4 --predefine="-DMBED_ROM_START=0x0" --predefine="-DMBED_RAM1_SIZE=0x10000" --predefine="-DXIP_ENABLE=0" --predefine="-DMBED_RAM_SIZE=0x30000" --any_contingency --predefine="-DMBED_RAM1_START=0x1fff0000" --predefine="-DMBED_ROM_SIZE=0x100000"
  group BUILD
    ./BUILD/K64F/ARMC6/: mbed_config.h
  group KMV_LAB2A_Hello_World
    ./: main.cpp
    ./: mbed_config.h
  group mbed-os
    ./mbed-os/drivers/source/: AnalogIn.cpp AnalogOut.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp DigitalIn.cpp DigitalInOut.cpp DigitalOut.cpp Ethernet.cpp FlashIAP.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp MbedCRC.cpp PortIn.cpp PortInOut.cpp PortOut.cpp PwmOut.cpp QSPI.cpp RawSerial.cpp ResetReason.cpp Serial.cpp SerialBase.cpp SerialWireOutput.cpp SPI.cpp SPISlave.cpp TableCRC.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp UARTSerial.cpp Watchdog.cpp
    ./mbed-os/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h ResetReason.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h USBAudio.h USBCDC.h USBCDC_ECM.h USBHID.h USBKeyboard.h USBMIDI.h USBMouse.h USBMouseKeyboard.h USBMSD.h USBSerial.h Watchdog.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api/: analogin_api.c analogout_api.c dma_api.c dma_api_hal.h flash_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c lp_ticker.c objects.h PeripheralPins.h pinmap.c port_api.c PortNames.h qspi_api.c rtc_api.c sleep.c
    ./mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.cpp LowPowerTickerWrapper.h lp_ticker_api.h mbed_compat.c mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_gpio_irq.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_lp_ticker_wrapper.cpp mbed_lp_ticker_wrapper.h mbed_pinmap_common.c mbed_pinmap_default.c mbed_ticker_api.c mbed_us_ticker_api.c mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h reset_reason_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h spm_api.h static_pinmap.cpp static_pinmap.h ticker_api.h trng_api.h us_ticker_api.h watchdog_api.h
    ./mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mbed_tz_context.c mpu_armv7.h mpu_armv8.h tz_context.h
    ./mbed-os/drivers/internal/: AsyncOp.h ByteBuffer.h EndpointResolver.h LinkedList.h LinkedListBase.h LinkEntry.h MIDIMessage.h OperationList.h OperationListBase.h PolledQueue.h TableCRC.h Task.h TaskBase.h TaskQueue.h USBAudio_Types.h USBDescriptor.h USBDevice.h USBDevice_Types.h USBHID_Types.h
    ./mbed-os/platform/source/: ATCmdParser.cpp CallChain.cpp CriticalSectionLock.cpp CThunkBase.cpp DeepSleepLock.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_application.c mbed_assert.c mbed_atomic_impl.c mbed_board.c mbed_crash_data_offsets.h mbed_critical.c mbed_error.c mbed_error_hist.c mbed_error_hist.h mbed_interface.c mbed_mem_trace.cpp mbed_mktime.c mbed_mpu_mgmt.c mbed_os_timer.cpp mbed_os_timer.h mbed_poll.cpp mbed_power_mgmt.c mbed_retarget.cpp mbed_rtc_time.cpp mbed_sdk_boot.c mbed_semihost_api.c mbed_stats.c mbed_thread.cpp mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp Stream.cpp SysTimer.cpp SysTimer.h
    ./mbed-os/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_atomic.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_thread.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.h toolchain.h Transaction.h wait_api.h
    ./mbed-os/features/storage/blockdevice/: BlockDevice.h BufferedBlockDevice.cpp BufferedBlockDevice.h ChainingBlockDevice.cpp ChainingBlockDevice.h ExhaustibleBlockDevice.cpp ExhaustibleBlockDevice.h FlashSimBlockDevice.cpp FlashSimBlockDevice.h HeapBlockDevice.cpp HeapBlockDevice.h MBRBlockDevice.cpp MBRBlockDevice.h ObservingBlockDevice.cpp ObservingBlockDevice.h ProfilingBlockDevice.cpp ProfilingBlockDevice.h ReadOnlyBlockDevice.cpp ReadOnlyBlockDevice.h SlicingBlockDevice.cpp SlicingBlockDevice.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/: cmsis.h cmsis_nvic.h fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: crc.c crc.h device.h fsl_clock_config.c fsl_clock_config.h fsl_phy.c fsl_phy.h mbed_overrides.c PeripheralNames.h PeripheralPinMaps.h PeripheralPins.c PinNames.h
    ./mbed-os/platform/internal/: CThunkBase.h mbed_atomic_impl.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/: dma_reqs.h mbed_crc_api.c peripheral_clock_defines.h pwmout_api.c reset_reason.c serial_api.c spi_api.c storage_driver.c trng_api.c us_ticker.c us_ticker_defines.h watchdog_api.c
    ./mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    ./mbed-os/platform/source/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/: fsl_common.c
    ./mbed-os/features/storage/kvstore/include/: KVStore.h
    ./mbed-os/: mbed.h
    ./mbed-os/cmsis/: mbed_cmsis_conf.h RTE_Components.h
    ./mbed-os/platform/source/TARGET_CORTEX_M/: mbed_fault_handler.c mbed_fault_handler.h
    ./mbed-os/hal/mpu/: mbed_mpu_v7m.c mbed_mpu_v8m.c
    ./mbed-os/platform/source/minimal-printf/: mbed_printf_armlink_overrides.c mbed_printf_implementation.c mbed_printf_implementation.h mbed_printf_wrapper.c
    ./mbed-os/targets/TARGET_Freescale/: mbed_rtx.h USBEndpoints_Kinetis.h USBPhy_Kinetis.cpp USBPhyHw.h
    ./mbed-os/hal/usb/: mbed_usb_phy.cpp usb_phy_api.h USBPhy.h USBPhyEvents.h USBPhyTypes.h
    ./mbed-os/platform/cxxsupport/: mstd_mutex.cpp
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD/: startup_MK64F12.S
